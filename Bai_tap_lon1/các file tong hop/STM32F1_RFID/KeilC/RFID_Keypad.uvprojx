# Keil uVision project RFID_Keypad.uvprojx, settings and files
target STM32F1_RFID (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c define: STM32F10X_M, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\..\RFID_VCT6;..\User;..\..\..\..\..\..\STM32F1_RFID\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\..\STM32F1_RFID\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\..\..\STM32F1_RFID\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\..\STM32F1_RFID\User;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f1_delay.c stm32f1_rc522.c stm32f10x_it.c usart.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_sdio.c
    ../User/: stm32f1_delay.h stm32f10x_it.h stm32f10x_conf.h stm32f1_rc522.h
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
